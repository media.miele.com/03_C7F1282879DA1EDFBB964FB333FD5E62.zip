Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 4f1ace0f-7cd9-42e6-bb3f-b7613d1b1b7a, NumberOfSaves: 1]
File name: 0001
Time: 2025-02-13T08:39:35+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 09289880_GB_KM2354:26235450_GB_9289880_KM2354, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 888 mm; Height: 75 mm; Depth: 508 mm
Classification: E1090320 Uniformat (Uniformat); Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_CLST, <Unnamed>, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Gas, z_Miele_Connection_Electric, z_Miele_Design_Cast
Pset_BuildingElementProxyCommon - Reference: 26235450_GB_9289880_KM2354; sets with these values: 2

# IfcDistributionPort, Port_355108_1
Description: Flow; FlowDirection: SOURCEANDSINK
